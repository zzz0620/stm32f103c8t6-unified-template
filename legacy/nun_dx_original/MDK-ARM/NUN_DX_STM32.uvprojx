# Keil uVision project NUN_DX_STM32.uvprojx, settings and files
target NUN_DX_STM32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: NUN_DX_STM32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\DX_driver;../DX_common;../DX_debug;../DX_device;..\DX_control;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c DX_driver_timer_callback.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
    ../Core/Src/: stm32f1xx_hal_i2c.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group DX_driver
    ../DX_driver/: DX_driver_gpio.c DX_driver_gpio.h DX_driver_delay.c DX_driver_delay.h DX_driver_uart.c DX_driver_uart.h DX_driver_adc.c DX_driver_adc.h DX_driver_i2c.c DX_driver_i2c.h DX_driver_spi.c DX_driver_spi.h DX_driver_timer.c DX_driver_timer.h DX_driver_timer_trigger.c DX_driver_timer_trigger.h DX_driver_timer_encoder.c DX_driver_timer_encoder.h DX_driver_pwm.c DX_driver_pwm.h DX_driver_exti.c DX_driver_exti.h DX_driver_dma.c DX_driver_dma.h
  group DX_driver_common
    ../DX_common/: DX_common_font.c DX_common_typedef.h DX_common_fifo.c DX_common_headfile.h DX_common_interrupt.c DX_common_interrupt.h DX_config.h
  group DX_debug
    ../DX_debug/: DX_debug.c DX_debug.h
  group DX_device
    ../DX_device/: DX_device_0.9_i2c_oled.c DX_device_0.9_i2c_oled.h DX_device_tb6612.c DX_device_tb6612.h DX_device_i2c_mpu6050.c DX_device_i2c_mpu6050.h DX_device_servo.c DX_device_servo.h DX_device_key.c DX_device_key.h DX_device_as5600.c DX_device_as5600.h DX_device_aht10.c DX_device_aht10.h DX_device_at24c64.c DX_device_at24c64.h DX_device_bh1750.c DX_device_bh1750.h DX_device_st7789.c DX_device_st7789.h DX_device_zdt_emm_v5.c
  group DX_control
    ../DX_control/: DX_control_pid.c DX_control_pid.h
  group DX_State-machine
    ../DX_State-machine/: State_Machine.c State_Machine.h
software components: CMSIS:CORE 4.3.0
