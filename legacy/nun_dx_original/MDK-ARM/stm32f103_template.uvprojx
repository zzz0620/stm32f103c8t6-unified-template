# Keil uVision project stm32f103_template.uvprojx, settings and files
target stm32f103_template (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103_template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../app/dart_board;../components/template;../components/loadcell;../components/nun_dx/common;../components/nun_dx/control;../components/nun_dx/debug;../components/nun_dx/device;../components/nun_dx/driver;../components/nun_dx/state_machine;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/Startup
    ./: startup_stm32f103xb.s
  group Application/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c usart.c tim.c can.c stm32_template_port.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c system_stm32f1xx.c
  group Components/Template
    ../components/template/: stm32_template.c
  group Components/LoadCell
    ../components/loadcell/: loadcell.c loadcell_service.c
  group Application/DartBoard
    ../app/dart_board/: font.c oled.c oled_ui.c
  group Components/NUN_DX/Common
    ../components/nun_dx/common/: DX_common_fifo.c DX_common_font.c DX_common_interrupt.c
    ../components/nun_dx/control/: DX_control_pid.c
    ../components/nun_dx/debug/: DX_debug.c
    ../components/nun_dx/state_machine/: state_machine.c
  group Components/NUN_DX/Drivers
    ../components/nun_dx/driver/: DX_driver_adc.c DX_driver_delay.c DX_driver_dma.c DX_driver_exti.c DX_driver_gpio.c DX_driver_i2c.c DX_driver_pwm.c DX_driver_spi.c DX_driver_timer.c DX_driver_timer_encoder.c DX_driver_timer_trigger.c DX_driver_uart.c
  group Components/NUN_DX/Devices
    ../components/nun_dx/device/: DX_device_aht10.c DX_device_as5600.c DX_device_at24c64.c DX_device_bh1750.c DX_device_i2c_mpu6050.c DX_device_i2c_oled.c DX_device_key.c DX_device_servo.c DX_device_st7789.c DX_device_tb6612.c DX_device_zdt_emm_v5.c
  group Drivers/STM32F1xx_HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
