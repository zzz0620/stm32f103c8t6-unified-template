# Keil uVision project stm32f103_template.uvprojx, settings and files
target stm32f103_template (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103_template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Object;../Components/Template;../Components/NUN_DX/common;../Components/NUN_DX/control;../Components/NUN_DX/debug;../Components/NUN_DX/device;../Components/NUN_DX/driver;../Components/NUN_DX/state_machine;../Components/NUN_DX/zdt;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  asm include: ../Core/Inc;../Object;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: usart_tsak.c iic_task.c main.c gpio.c freertos.c can.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/Object
    ../Object/: loadcell.c font.c oled.c oled_ui.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/User/Template
    ../Core/Src/: stm32_template_port.c
    ../Components/Template/: stm32_template.c
  group Components/NUN_DX/Common
    ../Components/NUN_DX/common/: DX_common_fifo.c DX_common_font.c DX_common_interrupt.c
    ../Components/NUN_DX/control/: DX_control_pid.c
    ../Components/NUN_DX/debug/: DX_debug.c
    ../Components/NUN_DX/state_machine/: State_Machine.c
  group Components/NUN_DX/Drivers
    ../Components/NUN_DX/driver/: DX_driver_adc.c DX_driver_delay.c DX_driver_dma.c DX_driver_exti.c DX_driver_gpio.c DX_driver_i2c.c DX_driver_pwm.c DX_driver_spi.c DX_driver_timer.c DX_driver_timer_encoder.c DX_driver_timer_trigger.c DX_driver_uart.c
  group Components/NUN_DX/Devices
    ../Components/NUN_DX/device/: DX_device_0.9_i2c_oled.c DX_device_aht10.c DX_device_as5600.c DX_device_at24c64.c DX_device_bh1750.c DX_device_i2c_mpu6050.c DX_device_key.c DX_device_servo.c DX_device_st7789.c DX_device_tb6612.c DX_device_zdt_emm_v5.c
  group Drivers/HAL/Optional
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c
software components: CMSIS:CORE 4.3.0
